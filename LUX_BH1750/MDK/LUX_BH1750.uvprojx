# Keil uVision project LUX_BH1750.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LUX_BH1750
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ../SRC/: main.c tim2.c tim2.h uart.c uart.h app_i2c.c app_i2c.h bh1750.c bh1750.h defines.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:I2C 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
