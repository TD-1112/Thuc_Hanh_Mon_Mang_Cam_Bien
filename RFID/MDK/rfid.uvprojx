# Keil uVision project rfid.uvprojx, settings and files
target RFID (6140000::V6.14::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rfid
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ../USER/: rfid.h main.c rfid.c
  group lib_core
    ../USER/: lib_gpio.h lib_uart.h lib_gpio.c lib_uart.c lib_spi.h lib_spi.c SysTick.h SysTick.c
  group message
    ../USER/: fsm.c math.c message.c fsm.h math.h message.h
software components: CMSIS:CORE 6.1.1, CMSIS:OS Tick:SysTick 1.0.5, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:SPI 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
